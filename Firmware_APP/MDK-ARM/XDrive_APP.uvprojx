# Keil uVision project XDrive_APP.uvprojx, settings and files
target XDrive_APP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: XDrive_APP +hex
  AfterMake: fromelf --bin ".\XDrive_APP\XDrive_APP.axf" --output ".\BIN\xdrive_app.bin"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Base_Drivers;..\Base_Math;..\Config;..\Control;..\Data_Link;..\Debug;..\Kernel;..\Demo;..\userApp\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\Config\X _Drive.sct
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c adc.c dma.c gpio.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_can.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Base_Drivers
    ../Base_Drivers/: kernel_port.c mt6816.c hw_elec.c signal_port.c uart_mixed.c
  group Base_Math
    ../Base_Math/: rein_math.c sin_form.c
  group Config
    ../Config/: stockpile_f103cb.c
  group Control
    ../Control/: control_config.c motor_control.c encode_cali.c Location_Tracker.c Speed_Tracker.c Current_Tracker.c Move_Reconstruct.c Location_Interp.c power_detect.c
  group Debug
    ../Debug/: button.c ssd1306.c xdrive_ui.c
  group Kernel
    ../Kernel/: loop.c loop_it.c
  group UserApp
    ../userApp/: xdCom.c crc16modbus.c bsp_delay.c
software components: CMSIS:CORE 4.3.0
